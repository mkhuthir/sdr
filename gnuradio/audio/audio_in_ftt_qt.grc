options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: samp_rate/2
    fftsize: '4096'
    rate: '30'
    showports: 'True'
    showrf: 'True'
    type: float
  states: {}

connections:
- [audio_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
