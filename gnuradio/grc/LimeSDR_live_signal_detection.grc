options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: LimeSDR_live_signal_detection
    output_language: python
    title: Inspector Live Signal Detection
  states: {}

blocks:
- name: cent_freq
  id: variable
  parameters:
    value: 95e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: thres
  id: variable_qtgui_range
  parameters:
    label: Threshold
    start: '-120'
    step: '1'
    stop: '50'
    value: '-65'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: inspector_qtgui_sink_vf_0
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: cent_freq
    fft_len: fft_size
    manual: 'False'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.2'
    fft_len: fft_size
    logfile: ''
    min_bw: '10000'
    quant: '0.001'
    samp_rate: samp_rate
    sensitivity: ' 0.2'
    threshold: thres
    window: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: auto
    calibrate_dciq: Disabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: ''
    gain_generic: '20'
    gfir_bandwidth: '0'
    link_format: i12
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: 20e6
    nco_offset: '0'
    override_lms7002m_rx_gains: Disabled
    rf_freq: cent_freq
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}

connections:
- [inspector_qtgui_sink_vf_0, map_out, blocks_message_debug_0, print]
- [inspector_signal_detector_cvf_0, '0', inspector_qtgui_sink_vf_0, '0']
- [inspector_signal_detector_cvf_0, map_out, inspector_qtgui_sink_vf_0, map_in]
- [limesuiteng_sdrdevice_source_0, '0', inspector_signal_detector_cvf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
