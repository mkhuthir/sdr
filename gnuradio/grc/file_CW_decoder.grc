options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    description: CW Decoder
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: file_CW_decoder
    output_language: python
    title: CW Decoder
  states: {}

blocks:
- name: AGC_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,150,1,50
    label: AGC Gain
    min_len: '10'
    start: '1'
    step: '1'
    stop: '100'
    value: '2'
  states: {}
- name: CW_LPF
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_CW/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: CW_wpm
  id: variable
  parameters:
    value: '20'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 7075e3
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fft_y_max
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: fft_y_min
  id: variable
  parameters:
    value: '-110'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: samp_rate_CW
  id: variable
  parameters:
    value: '800'
  states: {}
- name: sig_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,150,1,50
    label: Sig. Gain
    min_len: '10'
    start: '1'
    step: '1'
    stop: '100'
    value: '2'
  states: {}
- name: thresh_high
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,150,1,50
    label: Threshold High
    min_len: '10'
    start: '0.02'
    step: '0.01'
    stop: '2'
    value: '0.1'
  states: {}
- name: thresh_low
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,150,1,50
    label: Threshold Low
    min_len: '10'
    start: '0.00'
    step: '0.01'
    stop: '0.50'
    value: '0.05'
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,150,1,50
    label: Tune Freq
    min_len: '10'
    start: center_freq-samp_rate/2
    step: '1'
    stop: center_freq+samp_rate/2
    value: '7047713'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: AGC_gain
    max_gain: '100000'
    rate: samp_rate_CW/80
    reference: '1'
    type: float
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: thresh_low
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: thresh_high
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: 2 channels > IQ Complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: sig_gain
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_high
    init: '0'
    low: thresh_low
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: File Sample Rate
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Recorded file
    file: /home/mkhuthir/rfdata/wav/CW/SDRuno_20200908_233405Z_7075kHz_CW.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      # Changed to gr.basic_block to handle mismatched input and output rates
      class blk(gr.basic_block): 
          def __init__(self, sample_rate=800, wpm=20):
              """Accepts morse code signal and emits decoded streaming bytes (Integer 8)"""
              gr.basic_block.__init__(
                  self,
                  name='Morse Decoder GUI',
                  in_sig=[np.float32],
                  out_sig=[np.int8]  # FIX: Set to np.int8 to turn your output port PURPLE
              )
              self.sample_rate = sample_rate
              self.wpm = wpm
              
              # Morse timing variables
              self.dit_len = int((1.2 / self.wpm) * self.sample_rate)
              self.max_dit = int(self.dit_len * 2.0)
              self.min_space = int(self.dit_len * 2.0)
              self.min_word = int(self.dit_len * 5.0)

              # State tracking
              self.current_state = 0
              self.state_duration = 0
              self.current_char = ""
              self.output_queue = []  # Buffer to store decoded characters before outputting

              self.morse_dict = {
                  '.-': 'A', '-...': 'B', '-.-.': 'C', '-..': 'D', '.': 'E',
                  '..-.': 'F', '--.': 'G', '....': 'H', '..': 'I', '.---': 'J',
                  '-.-': 'K', '.-..': 'L', '--': 'M', '-.': 'N', '---': 'O',
                  '.--.': 'P', '--.-': 'Q', '.-.': 'R', '...': 'S', '-': 'T',
                  '..-': 'U', '...-': 'V', '.--': 'W', '-..-': 'X', '-.--': 'Y',
                  '--..': 'Z', '-----': '0', '.----': '1', '..---': '2', '...--': '3',
                  '....-': '4', '.....': '5', '-....': '6', '--...': '7', '---..': '8',
                  '----.': '9', '.-.-.-': '.', '--..--': ',', '..--..': '?', '-....-': '-'
              }

          def decode_element(self):
              """Translates accumulated dits/dahs into a character byte."""
              if self.current_char:
                  char = self.morse_dict.get(self.current_char, '*')
                  self.output_queue.append(ord(char))
                  self.current_char = ""

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              
              # 1. Process all incoming high-speed audio samples
              for sample in in0:
                  sample_state = 1 if sample > 0.5 else 0
                  
                  if sample_state == self.current_state:
                      self.state_duration += 1
                      
                      # Check for word space timeout
                      if self.current_state == 0 and self.state_duration == self.min_word:
                          if self.current_char:
                              self.decode_element()
                          self.output_queue.append(ord(" "))
                  else:
                      if self.current_state == 1:
                          if self.state_duration < self.max_dit:
                              self.current_char += "."
                          else:
                              self.current_char += "-"
                      else:
                          if self.state_duration >= self.min_space:
                              self.decode_element()
                      
                      self.current_state = sample_state
                      self.state_duration = 1

              # 2. Tell the scheduler how many input samples we processed
              self.consume(0, len(in0))

              # 3. Write decoded text bytes out to the purple port buffer
              n_output = min(len(out0), len(self.output_queue))
              if n_output > 0:
                  for i in range(n_output):
                      out0[i] = self.output_queue.pop(0)
                  return n_output
              else:
                  return 0
    sample_rate: samp_rate_CW
    wpm: CW_wpm
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_freq-center_freq
    decim: '1'
    samp_rate: samp_rate
    taps: CW_LPF
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Freq        WPM
      7027706    20
      7037763    12
      7047713    20
      7054461    15
    note: Morse Freqs
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 0,0,1,150
    legend: 'False'
    name: '"Baseband"'
    type: complex
    ymax: fft_y_max
    ymin: fft_y_min
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_CW
    color1: '"green"'
    fc: tune_freq
    fftsize: int(fft_size/4)
    grid: 'True'
    gui_hint: 0,150,1,50
    legend: 'False'
    name: '"Selected Signal"'
    type: complex
    ymax: fft_y_max
    ymin: fft_y_min
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color4: cyan
    grid: 'True'
    gui_hint: 7,0,1,200
    label1: Signal
    label2: Demod
    label3: Threshold High
    label4: Threshold Low
    name: '"CW Signal"'
    nconnections: '4'
    size: samp_rate_CW*2
    srate: samp_rate_CW
    type: float
    ymax: '6'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 1,8,5,142
    int_max: fft_y_max
    int_min: fft_y_min
    legend: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_CW
    type: ccc
  states: {}
- name: show_text_0
  id: show_text
  parameters:
    gui_hint: 8,1,1,200
    label: Decoded Text
    maxlines: '3'
    splitlength: '225'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: CW_sig
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: CW_sig
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_threshold_ff_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '3']
- [analog_const_source_x_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_agc_xx_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [epy_block_0, '0', show_text_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
