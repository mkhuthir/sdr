options:
  parameters:
    author: Muthanna Alwahash
    category: Custom
    copyright: (c) 2026
    description: CW Decoder
    generate_options: qt_gui
    id: file_CW_decoder
    output_language: python
    title: CW Decoder
  states: {}

blocks:
- name: AGC_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,50,1,50
    label: AGC Gain
    min_len: '10'
    start: '1'
    step: '1'
    stop: '100'
    value: '2'
  states: {}
- name: CW_LPF
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_CW/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: CW_wpm
  id: variable
  parameters:
    value: '20'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 7075e3
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fft_y_max
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: fft_y_min
  id: variable
  parameters:
    value: '-110'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: samp_rate_CW
  id: variable
  parameters:
    value: '800'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: thresh_high
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,150,1,50
    label: Threshold High
    min_len: '10'
    start: '0.02'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: thresh_low
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,100,1,50
    label: Threshold Low
    min_len: '10'
    start: '0.00'
    step: '0.01'
    stop: '0.10'
    value: '0.05'
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,50
    label: Tune Freq
    min_len: '10'
    start: center_freq-samp_rate/2
    step: '1'
    stop: center_freq+samp_rate/2
    value: '7047713'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: AGC_gain
    max_gain: '100000'
    rate: samp_rate_CW/80
    reference: '1'
    type: float
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: thresh_low
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: thresh_high
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: 2 channels > IQ Complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_high
    init: '0'
    low: thresh_low
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: File Sample Rate
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Recorded file
    file: /home/mkhuthir/rfdata/wav/CW/SDRuno_20200908_233405Z_7075kHz_CW.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: display_utils_text_terminal_sink_0
  id: display_utils_text_terminal_sink
  parameters:
    max_lines: '100'
    title: '"Text Terminal"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block): # other base classes are basic_block, decim_block, interp_block\n    def __init__(self, sample_rate=800, wpm=20): # only default arguments here\n        \"\"\"Accepts morse code signal and emits decoded charcters\n        Sample rate: Morse signal sample rate in Hz, default is 800Hz\n        WPM: Words per minute, default is 20\n        \"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Morse Decoder GUI',\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        self.sample_rate = sample_rate\n        self.wpm = wpm\n        \n        # Register a message output port for text strings\n        self.message_port_register_out(gr.pmt.mp(\"text_out\"))\n        \n        # Morse timing variables\n        self.dit_len = int((1.2 / self.wpm) * self.sample_rate)\n        self.max_dit = int(self.dit_len * 2.0)\n        self.min_space = int(self.dit_len * 2.0)\n        self.min_word = int(self.dit_len * 5.0)\n\n        # State tracking\n        self.current_state = 0\n        self.state_duration = 0\n        self.current_char = \"\"\n\n        self.morse_dict = {\n            '.-': 'A', '-...': 'B', '-.-.': 'C', '-..': 'D', '.': 'E',\n            '..-.': 'F', '--.': 'G', '....': 'H', '..': 'I', '.---': 'J',\n            '-.-': 'K', '.-..': 'L', '--': 'M', '-.': 'N', '---': 'O',\n            '.--.': 'P', '--.-': 'Q', '.-.': 'R', '...': 'S', '-': 'T',\n            '..-': 'U', '...-': 'V', '.--': 'W', '-..-': 'X', '-.--': 'Y',\n            '--..': 'Z', '-----': '0', '.----': '1', '..---': '2', '...--': '3',\n            '....-': '4', '.....': '5', '-....': '6', '--...': '7', '---..': '8',\n            '----.': '9', '.-.-.-': '.', '--..--': ',', '..--..': '?', '-....-': '-'\n        }\n        \n\n    def emit_string(self, text):\n        \"\"\"Broadcast text via PMT message.\"\"\"\n        # Convert standard Python string to a GNU Radio PMT object and publish it\n        pmt_msg = pmt.string_to_symbol(text)\n        self.message_port_pub(pmt.mp(\"text_out\"), pmt_msg)\n\n    def decode_element(self):\n        \"\"\"Translates accumulated dits/dahs into a character.\"\"\"\n        if self.current_char:\n            char = self.morse_dict.get(self.current_char, '[?]')\n            self.emit_string(char)\n            self.current_char = \"\"\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        \n        for sample in in0:\n            sample_state = 1 if sample > 0.5 else 0\n            \n            if sample_state == self.current_state:\n                self.state_duration += 1\n                \n                # Check for word space timeout\n                if self.current_state == 0 and self.state_duration > self.min_word:\n                    if self.current_char:\n                        self.decode_element()\n                        self.emit_string(\" \")\n                    self.state_duration = 0 \n            else:\n                if self.current_state == 1:\n                    if self.state_duration < self.max_dit:\n                        self.current_char += \".\"\n                    else:\n                        self.current_char += \"-\"\n                else:\n                    if self.state_duration >= self.min_space:\n                        self.decode_element()\n                \n                self.current_state = sample_state\n                self.state_duration = 1\n                \n        return len(in0)\n\n"
    sample_rate: samp_rate_CW
    wpm: CW_wpm
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      # Import PyQt5 classes for UI structure
      from PyQt5.QtWidgets import QWidget, QVBoxLayout, QTextEdit
      from PyQt5.QtCore import pyqtSignal, QObject

      class TextSignalEmitter(QObject):
          """
          Helper class to emit safe signals across threads.
          GNU Radio message handlers run on their own thread, 
          so updating Qt components must go through pyqtSignal.
          """
          append_text = pyqtSignal(str)

      class blk(gr.basic_block):
          def __init__(self, title="Text Terminal", max_lines=100):
              gr.basic_block.__init__(
                  self,
                  name='QT Text Display Sink',
                  in_sig=None,   # No streaming inputs
                  out_sig=None   # No streaming outputs
              )
              
              # Register an incoming message port for text packages
              self.message_port_register_in(pmt.intern('text_in'))
              self.set_msg_handler(pmt.intern('text_in'), self.handle_msg)
              
              # Store configuration parameters safely
              self.title = title
              self.max_lines = max_lines
              
              # CRITICAL FIX: Set GUI placeholders as None initially.
              # This keeps GRC background compilation happy on save!
              self.win = None
              self.text_edit = None
              self.emitter = None

          def _setup_gui(self):
              """Lazy initialization routine triggered safely at block runtime startup."""
              if self.win is not None:
                  return  # Already built
                  
              self.win = QWidget()
              self.win.setWindowTitle(self.title)
              layout = QVBoxLayout()
              
              self.text_edit = QTextEdit()
              self.text_edit.setReadOnly(True)  # Terminal style (Display only)
              layout.addWidget(self.text_edit)
              self.win.setLayout(layout)
              
              # Wire up our custom thread-safe signaling mechanism
              self.emitter = TextSignalEmitter()
              self.emitter.append_text.connect(self._safe_append_text)

          def handle_msg(self, msg):
              """Processes incoming PMT messages from the flowgraph thread."""
              # Ensure UI exists the absolute moment the first packet drops
              if self.win is None:
                  return
                  
              try:
                  # Extract plain text string from the Polymorphic Type (PMT) message
                  if pmt.is_pair(msg):
                      text_content = str(pmt.to_python(pmt.cdr(msg)))
                  elif pmt.is_symbol(msg):
                      text_content = pmt.symbol_to_string(msg)
                  else:
                      text_content = str(pmt.to_python(msg))
                      
                  # Emit the signal safely to the main Qt application thread
                  self.emitter.append_text.emit(text_content)
              except Exception as e:
                  if self.emitter:
                      self.emitter.append_text.emit(f"[Error parsing message: {str(e)}]")

          def _safe_append_text(self, text):
              """Appends the arriving string text straight onto the screen layout safely."""
              if self.text_edit:
                  self.text_edit.append(text)
                  
                  # Keep window clean by tracking total line limit constraints
                  document = self.text_edit.document()
                  if document.blockCount() > self.max_lines:
                      cursor = self.text_edit.textCursor()
                      cursor.movePosition(cursor.Start)
                      cursor.select(cursor.LineUnderCursor)
                      cursor.removeSelectedText()
                      cursor.deleteChar() # Deletes leftover newline character

          def work(self, input_items, output_items):
              # Trigger layout setup seamlessly during runtime thread startup phases
              if self.win is None:
                  self._setup_gui()
              return 0
    max_lines: '12'
    title: '"Decoded Text"'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_freq-center_freq
    decim: '1'
    samp_rate: samp_rate
    taps: CW_LPF
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 0,0,1,150
    legend: 'False'
    name: '"Baseband"'
    type: complex
    ymax: fft_y_max
    ymin: fft_y_min
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_CW
    color1: '"green"'
    fc: tune_freq
    fftsize: int(fft_size/4)
    grid: 'True'
    gui_hint: 0,150,1,50
    legend: 'False'
    name: '"Selected Signal"'
    type: complex
    ymax: fft_y_max
    ymin: fft_y_min
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color4: cyan
    grid: 'True'
    gui_hint: 2,0,1,200
    label1: Signal
    label2: Demod
    label3: Threshold High
    label4: Threshold Low
    name: '"CW Signal"'
    nconnections: '4'
    size: samp_rate_CW*5
    srate: samp_rate_CW
    type: float
    ymax: '6'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 1,5,1,145
    int_max: fft_y_max
    int_min: fft_y_min
    legend: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_CW
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: CW_sig
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: CW_sig
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_threshold_ff_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '3']
- [analog_const_source_x_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_mag_squared_0, '0', analog_agc_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [epy_block_0, text_out, epy_block_1, text_in]
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
