options:
  parameters:
    author: Muthanna Alwahash
    category: Custom
    copyright: (c) 2026
    description: CW Decoder
    generate_options: qt_gui
    id: file_CW_decoder
    output_language: python
    title: CW Decoder
  states: {}

blocks:
- name: AGC_gain
  id: variable_qtgui_range
  parameters:
    label: AGC Gain
    start: 1e3
    step: 1e3
    stop: 100e3
    value: 12e3
  states: {}
- name: AGC_rate
  id: variable_qtgui_range
  parameters:
    label: AGC Attack Decay Rate
    start: '1e-3'
    step: '1e-4'
    stop: '1e-2'
    value: '1e-3'
  states: {}
- name: CW_LPF
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_CW/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: CW_wpm
  id: variable
  parameters:
    value: '20'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 7075e3
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fft_y_max
  id: variable
  parameters:
    value: '-45'
  states: {}
- name: fft_y_min
  id: variable
  parameters:
    value: '-110'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: samp_rate_CW
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: thresh_high
  id: variable_qtgui_range
  parameters:
    label: Threshold High
    start: '0.7'
    step: '0.01'
    stop: '0.9'
    value: '0.75'
  states: {}
- name: thresh_low
  id: variable_qtgui_range
  parameters:
    label: Threshold Low
    start: '0.1'
    step: '0.01'
    stop: '0.6'
    value: '0.35'
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    label: Tune Freq
    start: center_freq-samp_rate/2
    step: '100'
    stop: center_freq+samp_rate/2
    value: 7.047e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: AGC_gain
    max_gain: '100000'
    rate: AGC_rate
    reference: '1.0'
    type: float
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: thresh_low
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: thresh_high
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: 2 channels > IQ Complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh_high
    init: '0'
    low: thresh_low
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: File Sample Rate
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Recorded file
    file: /home/mkhuthir/rfdata/wav/CW/SDRuno_20200908_233405Z_7075kHz_CW.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block): # other base classes are basic_block, decim_block, interp_block\n    def __init__(self, sample_rate=48000, wpm=20): # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Morse Decoder GUI',\n            in_sig=[np.float32],\n            out_sig=None\n        )\n        self.sample_rate = sample_rate\n        self.wpm = wpm\n        \n        # Register a message output port for text strings\n        self.message_port_register_out(gr.pmt.mp(\"text_out\"))\n        \n        # Morse timing variables\n        self.dit_len = int((1.2 / self.wpm) * self.sample_rate)\n        self.max_dit = int(self.dit_len * 2.0)\n        self.min_space = int(self.dit_len * 2.0)\n        self.min_word = int(self.dit_len * 5.0)\n\n        # State tracking\n        self.current_state = 0\n        self.state_duration = 0\n        self.current_char = \"\"\n        self.display_buffer = \"\"  # Keeps track of the running text string\n\n        self.morse_dict = {\n            '.-': 'A', '-...': 'B', '-.-.': 'C', '-..': 'D', '.': 'E',\n            '..-.': 'F', '--.': 'G', '....': 'H', '..': 'I', '.---': 'J',\n            '-.-': 'K', '.-..': 'L', '--': 'M', '-.': 'N', '---': 'O',\n            '.--.': 'P', '--.-': 'Q', '.-.': 'R', '...': 'S', '-': 'T',\n            '..-': 'U', '...-': 'V', '.--': 'W', '-..-': 'X', '-.--': 'Y',\n            '--..': 'Z', '-----': '0', '.----': '1', '..---': '2', '...--': '3',\n            '....-': '4', '.....': '5', '-....': '6', '--...': '7', '---..': '8',\n            '----.': '9', '.-.-.-': '.', '--..--': ',', '..--..': '?', '-....-': '-'\n        }\n        self.emit_string(\"hello\")\n\n    def emit_string(self, text):\n        \"\"\"Appends new text to the buffer and broadcasts it via PMT message.\"\"\"\n        self.display_buffer += text\n        # Cap display at last 100 characters so it doesn't grow infinitely\n        if len(self.display_buffer) > 100:\n            self.display_buffer = self.display_buffer[-100:]\n            \n        # Convert standard Python string to a GNU Radio PMT object and publish it\n        pmt_msg = pmt.string_to_symbol(self.display_buffer)\n        self.message_port_pub(pmt.mp(\"text_out\"), pmt_msg)\n\n    def decode_element(self):\n        \"\"\"Translates accumulated dits/dahs into a character.\"\"\"\n        if self.current_char:\n            char = self.morse_dict.get(self.current_char, '[?]')\n            self.emit_string(char)\n            self.current_char = \"\"\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        \n        for sample in in0:\n            sample_state = 1 if sample > 0.5 else 0\n            \n            if sample_state == self.current_state:\n                self.state_duration += 1\n                \n                # Check for word space timeout\n                if self.current_state == 0 and self.state_duration > self.min_word:\n                    if self.current_char:\n                        self.decode_element()\n                        self.emit_string(\" \")\n                    self.state_duration = 0 \n            else:\n                if self.current_state == 1:\n                    if self.state_duration < self.max_dit:\n                        self.current_char += \".\"\n                    else:\n                        self.current_char += \"-\"\n                else:\n                    if self.state_duration >= self.min_space:\n                        self.decode_element()\n                \n                self.current_state = sample_state\n                self.state_duration = 1\n                \n        return len(in0)\n\n"
    sample_rate: samp_rate_CW
    wpm: CW_wpm
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_freq-center_freq
    decim: '1'
    samp_rate: samp_rate
    taps: CW_LPF
    type: ccc
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 2,100,1,100
    is_pair: 'False'
    is_static: 'False'
    label: Morse Text
    type: string
    value: Hello
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 0,0,1,100
    legend: 'False'
    name: '"Baseband"'
    type: complex
    ymax: fft_y_max
    ymin: fft_y_min
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_CW
    color1: '"green"'
    fc: tune_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 0,100,1,100
    legend: 'False'
    name: '"Selected Signal"'
    type: complex
    ymax: fft_y_max
    ymin: fft_y_min
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,100
    label1: Signal
    label2: Threshold Min
    label3: Threshold Max
    name: '"CW Signal"'
    nconnections: '4'
    size: samp_rate_CW
    srate: samp_rate_CW
    type: float
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 1,5,1,95
    int_max: fft_y_max
    int_min: fft_y_min
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_CW
    fc: tune_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 1,105,1,95
    int_max: fft_y_max
    int_min: fft_y_min
    legend: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_CW
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_audio
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: CW_sig
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: audio_sig
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: CW_sig
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: audio_sig
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_threshold_ff_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '2']
- [analog_const_source_x_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', analog_agc_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [epy_block_0, text_out, qtgui_edit_box_msg_0, val]
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
