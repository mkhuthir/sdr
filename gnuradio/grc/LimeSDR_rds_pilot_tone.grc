options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    generate_options: qt_gui
    id: LimeSDR_rds_pilot_tone
    output_language: python
    title: Demodulating RDS Signals with 19 kHz Pilot Tone
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Center Frequency (MHz)
    start: '87.7'
    step: '0.1'
    stop: '107.9'
    value: '94.4'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,10,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: samp_rate_FM
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM demod
    gain: samp_rate_FM/(2*math.pi*75e3)
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: Filter 19 kHz pilot tone
    decim: int(samp_rate_FM/samp_rate_RDS)
    gain: '10'
    high_cutoff_freq: '19200'
    low_cutoff_freq: '18200'
    samp_rate: samp_rate_FM
    type: fir_filter_ccc
    width: '200'
    win: window.WIN_BLACKMAN
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: |-
      Convert real back
      to complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Triple center freq
      of pilot tone to
      57 kHz
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Mix 57 kHz tone
      with FM baseband
      to put RDS at 0 Hz
    type: complex
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: Filter out FM signal
    cutoff_freq: 100e3
    decim: int(samp_rate/samp_rate_FM)
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 20e3
    win: window.WIN_BLACKMAN
  states: {}
- name: filter_fft_low_pass_filter_1
  id: filter_fft_low_pass_filter
  parameters:
    comment: Filter RDS signal.
    cutoff_freq: '2400'
    decim: '1'
    gain: '20'
    samp_rate: samp_rate_RDS
    type: ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: auto
    calibrate_dciq: Enabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: ''
    gain_generic: rf_gain
    gfir_bandwidth: '0'
    link_format: i12
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: 20e6
    nco_offset: '0'
    override_lms7002m_rx_gains: Disabled
    rf_freq: center_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    grid: 'True'
    gui_hint: 11,0,10,10
    legend: 'False'
    name: RDS IQ Polar
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_FM
    color1: '"green"'
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 1,0,10,10
    legend: 'False'
    name: RF Spectrum
    type: complex
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_FM
    color1: '"green"'
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 1,10,10,10
    legend: 'False'
    name: FM Baseband Spectrum
    type: float
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_RDS
    color1: '"green"'
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 11,10,10,10
    legend: 'False'
    name: RF Spectrum
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '2']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', filter_fft_low_pass_filter_1, '0']
- [filter_fft_low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [filter_fft_low_pass_filter_1, '0', analog_agc_xx_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', filter_fft_low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
