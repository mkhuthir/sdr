options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    generate_options: qt_gui
    id: audio_in_fft
    output_language: python
    title: Audio in to FFT
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: samp_rate/2
    fftsize: '4096'
    rate: '30'
    showports: 'True'
    showrf: 'True'
    type: float
  states: {}

connections:
- [audio_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
