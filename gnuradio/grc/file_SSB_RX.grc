options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    description: SSB Receiver
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: file_SSB_RX
    output_language: python
    title: SSB Receiver
  states: {}

blocks:
- name: SSB_LPF
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_SSB/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 7075e3
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: fft_y_max
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: fft_y_min
  id: variable
  parameters:
    value: '-110'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: samp_rate_SSB
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,150,1,50
    label: Tune Freq
    min_len: '10'
    start: center_freq-samp_rate/2
    step: '100'
    stop: center_freq+samp_rate/2
    value: '7110000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,150,1,50
    label: Volume
    min_len: '10'
    start: '1'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: 2 channels > IQ Complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: File Sample Rate
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Recorded file
    file: /home/mkhuthir/rfdata/wav/CW/SDRuno_20200908_233405Z_7075kHz_CW.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_freq-center_freq
    decim: '1'
    samp_rate: samp_rate
    taps: SSB_LPF
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Freq
      7070250
      7110000
      7125240
    note: SSB Freqs
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 0,0,1,150
    legend: 'False'
    name: '"Baseband"'
    type: complex
    ymax: fft_y_max
    ymin: fft_y_min
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    fc: tune_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 0,150,1,50
    legend: 'False'
    name: '"Selected Signal"'
    type: complex
    ymax: fft_y_max
    ymin: fft_y_min
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 1,5,5,145
    int_max: fft_y_max
    int_min: fft_y_min
    legend: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_audio
    type: ccc
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
