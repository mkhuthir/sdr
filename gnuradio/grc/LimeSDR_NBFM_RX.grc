options:
  parameters:
    author: Muthanna Alwahash
    copyright: '2026'
    description: NBFM receiver
    generate_options: qt_gui
    id: LimeSDR_NBFM_RX
    output_language: python
    title: NBFM Receiver
  states: {}

blocks:
- name: LO_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0,1, 50
    label: LO Freq.
    start: '100'
    step: '0.1'
    stop: '200'
    value: '155.321'
  states: {}
- name: channel_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '-3000'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: LO_freq*1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0,1, 50
    label: RF Gain
    start: '0'
    step: '1'
    stop: '49.6'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate_audio_band
  id: variable
  parameters:
    value: int(samp_rate_audio_sink*5)
  states: {}
- name: samp_rate_audio_sink
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 0,1, 50
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0,1, 50
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1.00'
    value: '0.05'
    widget: slider
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate_audio_sink
    max_dev: 5e3
    quad_rate: samp_rate_audio_band
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: int(samp_rate/samp_rate_audio_band)
    taps: channel_filter
    type: ccc
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: auto
    calibrate_dciq: Enabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: ''
    gain_generic: gain
    gfir_bandwidth: '0'
    link_format: i16
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: 20e6
    nco_offset: '0'
    override_lms7002m_rx_gains: Disabled
    rf_freq: LO_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_audio_band
    fc: freq_tune
    fftsize: '1024'
    gui_hint: 4, 0,6, 50
    legend: 'False'
    type: complex
    ymax: '-10'
    ymin: '-180'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_audio_band
    fc: freq_tune
    fftsize: '1024'
    gui_hint: 10, 2,4, 48
    int_max: '-10'
    int_min: '-180'
    legend: 'False'
    type: complex
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [fft_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [fft_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', fft_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
