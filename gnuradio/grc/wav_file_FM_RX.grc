options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    description: RDS receiver from wave file
    generate_options: qt_gui
    id: wav_file_FM_RX
    output_language: python
    title: Wave file FM RX
  states: {}

blocks:
- name: FM_fsk_deviation_hz
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: RDS_LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 7.5e3
    gain: '1'
    samp_rate: samp_rate_FM_band
    width: 1.8e3
    win: window.WIN_HAMMING
  states: {}
- name: RDS_freq
  id: variable
  parameters:
    value: '57000'
  states: {}
- name: RDS_sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: SCA_LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 7.5e3
    gain: '1'
    samp_rate: samp_rate_FM_band
    width: 1.8e3
    win: window.WIN_HAMMING
  states: {}
- name: SCA_freq
  id: variable
  parameters:
    value: '67000'
  states: {}
- name: SCA_fsk_deviation_hz
  id: variable
  parameters:
    value: 7.5e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 88.11e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: 11*RDS_sps
    samp_rate: samp_rate_RDS
    sym_rate: samp_rate_RDS/RDS_sps
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samp_rate_FM_band
  id: variable
  parameters:
    value: samp_rate_audio_FM*5
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: samp_rate_SCA
  id: variable
  parameters:
    value: samp_rate_audio_SCA*4
  states: {}
- name: samp_rate_audio_FM
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_audio_SCA
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,100
    label: FM Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: volume2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,100
    label: SCA Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.4'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate_audio_SCA
    comment: SCA NBFM
    max_dev: SCA_fsk_deviation_hz
    quad_rate: samp_rate_SCA
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM Demod
    gain: samp_rate_FM_band/(2*math.pi*FM_fsk_deviation_hz)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate_FM_band/samp_rate_audio_FM)
    comment: Wideband FM Demod
    quad_rate: samp_rate_FM_band
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: FM Audio Mono
    samp_rate: samp_rate_audio_FM
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: SCA Audio
    ok_to_block: 'False'
    samp_rate: samp_rate_audio_SCA
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Wave file source
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: FM Volume
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: SCA Volume
    const: volume2
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Wave file sample rate
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Wave file
    file: /home/mkhuthir/rfdata/wav/FM_RDS/SDRuno_20200907_184033Z_88110kHz_FM_RDS.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: SCA_freq
    comment: SCA LPF
    decim: int(samp_rate_FM_band/samp_rate_SCA)
    samp_rate: samp_rate_FM_band
    taps: SCA_LPF_taps
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: RDS_freq
    comment: RDS LPF
    decim: int(samp_rate_FM_band/samp_rate_RDS)
    samp_rate: samp_rate_FM_band
    taps: RDS_LPF_taps
    type: fcc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    grid: 'True'
    gui_hint: 5,200,4,100
    legend: 'False'
    name: '"RDS Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    comment: Baseband Freq
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 5,0,4,100
    legend: 'False'
    name: '"Baseband"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_FM_band
    color1: '"green"'
    comment: FM Freq
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 9,0,4,100
    legend: 'False'
    name: FM Demod
    type: float
    ymax: '-10'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_SCA
    color1: '"green"'
    comment: SCA Freq LPF
    fc: '0'
    fftsize: fft_size
    grid: 'True'
    gui_hint: 9,100,4,100
    legend: 'False'
    name: '"SCA"'
    type: complex
    ymax: '-40'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_RDS
    color1: '"green"'
    comment: RDS Freq LPF
    fc: '0'
    fftsize: fft_size
    grid: 'True'
    gui_hint: 9,200,4,100
    legend: 'False'
    name: '"RDS"'
    type: complex
    ymax: '-40'
    ymin: '-90'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_FM_band
    comment: FM Waterfall
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    gui_hint: 13,8,4,92
    int_max: '-10'
    int_min: '-100'
    legend: 'False'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_SCA
    comment: SCA Waterfall LPF
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    gui_hint: 13,108,4,92
    int_max: '-40'
    int_min: '-100'
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_RDS
    comment: RDS Waterfall LPF
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    gui_hint: 13,208,4,92
    int_max: '-40'
    int_min: '-90'
    legend: 'False'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_FM_band
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Baseband
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: FM_demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: For FM Audio
    stream_id: Baseband
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: for SCA
    stream_id: FM_demod
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    comment: for RDS
    stream_id: FM_demod
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_1, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fir_filter_xxx_1_0, '0', analog_nbfm_rx_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', qtgui_freq_sink_x_0_1, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_1_0_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1_0_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_1_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [virtual_source_1_0, '0', freq_xlating_fir_filter_xxx_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
