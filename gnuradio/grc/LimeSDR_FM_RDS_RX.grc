options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    description: LimeSDR Stereo FM receiver and RDS Decoder
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: LimeSDR_FM_RDS_RX
    output_language: python
    title: LimeSDR Stereo FM receiver and RDS Decoder
  states: {}

blocks:
- name: Ch_LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 135e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: LO_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl@0:0, 0,1, 200
    label: LO Freq.
    min_len: '10'
    start: '87'
    step: '0.1'
    stop: '108'
    value: '94.4'
  states: {}
- name: LR_LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 15e3
    gain: '1.0'
    samp_rate: samp_rate_audio_band
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: Pilot_BPF_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: samp_rate_audio_band
    type: complex_band_pass
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: RDS2_DS1_freq
  id: variable
  parameters:
    value: '66500'
  states: {}
- name: RDS2_DS2_freq
  id: variable
  parameters:
    value: '71250'
  states: {}
- name: RDS2_DS3_freq
  id: variable
  parameters:
    value: '76000'
  states: {}
- name: RDS_LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 7.5e3
    gain: '1.0'
    samp_rate: samp_rate_FMMPX
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: RDS_freq
  id: variable
  parameters:
    value: '57000'
  states: {}
- name: RDS_sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: SCA_LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 7.5e3
    gain: '1'
    samp_rate: 'samp_rate_FMMPX '
    width: 1.8e3
    win: window.WIN_HAMMING
  states: {}
- name: SCA_freq
  id: variable
  parameters:
    value: '76000'
  states: {}
- name: SCA_fsk_deviation_hz
  id: variable
  parameters:
    value: 7.5e3
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: LO_freq*1e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl@1:1,0,1,200
    label: RF Gain
    min_len: '10'
    start: '0'
    step: '1'
    stop: '49.6'
    value: '25'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: 11*RDS_sps
    samp_rate: samp_rate_RDS
    sym_rate: samp_rate_RDS/RDS_sps
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate_FMMPX
  id: variable
  parameters:
    value: int(200e3)
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: '19000'
  states: {}
- name: samp_rate_SCA
  id: variable
  parameters:
    value: samp_rate_audio_SCA*4
  states: {}
- name: samp_rate_audio_SCA
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: samp_rate_audio_band
  id: variable
  parameters:
    value: int(samp_rate_audio_sink*5)
  states: {}
- name: samp_rate_audio_sink
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: update_period
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl@2:0,0,1,200
    label: Update
    min_len: '10'
    start: '0.0001'
    step: '0.0001'
    stop: '0.0500'
    value: '0.0100'
    widget: eng_slider
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl@0:1,0,1, 100
    label: Volume
    min_len: '10'
    start: '-20'
    step: '0.5'
    stop: '1'
    value: '-6'
  states: {}
- name: volume2
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl@0:1,100,1, 100
    label: SCA Volume
    min_len: '10'
    start: '-20'
    step: '0.5'
    stop: '1'
    value: '-6'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '53'
    max_gain: '1000'
    rate: '2e-3'
    reference: '0.585'
    type: complex
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    comment: 75us = US, 50us = EUR
    samp_rate: samp_rate_audio_sink
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    comment: 75us = US, 50us = EUR
    samp_rate: samp_rate_audio_sink
    tau: '50e-6'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate_audio_SCA
    comment: SCA NBFM
    max_dev: SCA_fsk_deviation_hz
    quad_rate: samp_rate_SCA
    tau: '75e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    comment: Phase Lock on 19KHz
    max_freq: 2 * math.pi * 19020 / samp_rate_audio_band
    min_freq: 2 * math.pi * 18980 / samp_rate_audio_band
    w: '0.001'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM Demodulator
    gain: samp_rate_FMMPX / (2*math.pi*75e3)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Audio Output
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: SCA Audio
    ok_to_block: 'False'
    samp_rate: samp_rate_audio_SCA
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: (L+R)+(L-R)=2L
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Pilot PBF delay
    delay: (len(Pilot_BPF_taps) - 1) // 2
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Mix L & R
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: L Volume
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: R Volume
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: SCA Volume
    const: 10**(1.*(volume2)/10)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: 19KHz > 38KHz
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: Shift (L-R) to 0KHz
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: (L+R)-(L-R)=2R
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ctrl
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,200
    label0: Tuning
    label1: SDR
    label2: GUI
    num_tabs: '3'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2*math.pi / 100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Pilot PBF @ 19 KHz
    decim: '1'
    taps: Pilot_BPF_taps
    type: fcc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    comment: L+R (Mono)
    decim: int(samp_rate_audio_band/samp_rate_audio_sink)
    taps: LR_LPF_taps
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    comment: L-R (Stereo)
    decim: '5'
    taps: LR_LPF_taps
    type: fff
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps_manchester
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: FM Channel Select
    decim: int(samp_rate/samp_rate_FMMPX)
    samp_rate: samp_rate
    taps: Ch_LPF_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: RDS_freq
    decim: '1'
    samp_rate: samp_rate_FMMPX
    taps: RDS_LPF_taps
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: SCA_freq
    comment: SCA LPF
    decim: int(samp_rate_FMMPX /samp_rate_SCA)
    samp_rate: 'samp_rate_FMMPX '
    taps: SCA_LPF_taps
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: auto
    calibrate_dciq: Enabled
    channel_indexes: '[0]'
    chip_index: '0'
    comment: SDR
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: ''
    gain_generic: rf_gain
    gfir_bandwidth: '0'
    link_format: i16
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: 20e6
    nco_offset: '0'
    override_lms7002m_rx_gains: Disabled
    rf_freq: LO_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: main
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,200
    label0: Baseband signal
    label1: FM MPX
    label2: FM Audio
    label3: FM RDS1
    num_tabs: '4'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      L+R   : 30 Hz - 15 kHz  Mono (15k BW)
      Pilot : 19 kHz 
      L-R     : 23 kHz - 53 kHz Stereo - Center 2x19kHz = 38kHz (30k BW)

      RDS   : 57 kHz - 3x19kHz

      RDS2 DS1 66.5 kHz - 3.5x19kHz
      RDS2 DS2 71.25 kHz -  3.75x19kHz
      RDS2 DS3 76 kHz - 4x19kHz

      SCA   : 41kHz, 67kHz, 92kHz
    note: FM Ch Baseband
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    grid: 'True'
    gui_hint: main@3:7,0,2,20
    legend: 'False'
    name: '"RDS1 Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_audio_sink
    color1: '"green"'
    fc: '0'
    fftsize: fft_size
    grid: 'True'
    gui_hint: main@2:0,0,1,200
    legend: 'False'
    name: '"Audio"'
    type: complex
    update_time: update_period
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_FMMPX
    color1: '"green"'
    comment: FM MPX FFT
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    grid: 'True'
    gui_hint: main@1:0,0,1,200
    label: '""'
    legend: 'False'
    name: '"FM MPX Spectrum"'
    type: float
    update_time: update_period
    ymax: '-10'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    comment: Baseband FFT
    fc: freq_tune
    fftsize: fft_size
    grid: 'True'
    gui_hint: main@0:0,0,1,200
    legend: 'False'
    name: '"Baseband Signal"'
    type: complex
    update_time: update_period
    ymax: '-10'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_RDS
    fc: '0'
    fftsize: fft_size
    grid: 'True'
    gui_hint: main@3:9,0,2,20
    legend: 'False'
    name: ''
    type: complex
    update_time: update_period
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    comment: |-
      RDS group is 104 bits (4x26 bits blocks)
      26 block = 16 data + 10 error checking
    grid: 'True'
    gui_hint: main@3:9,23,2,175
    ncols: '104'
    nrows: '25'
    samp_rate: samp_rate_RDS
    type: float
    update_time: update_period
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    entags: 'False'
    grid: 'True'
    gui_hint: main@3:7,20,2,171
    legend: 'False'
    name: RDS1 Bits
    size: '104'
    srate: samp_rate_RDS
    type: float
    update_time: update_period
    ylabel: '""'
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_FMMPX
    comment: FM MPX Waterfall
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    grid: 'True'
    gui_hint: main@1:1,4,1,196
    int_max: '-10'
    int_min: '-100'
    legend: 'False'
    type: float
    update_time: update_period
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_audio_sink
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    grid: 'True'
    gui_hint: main@2:1,4,1,196
    int_max: '-10'
    int_min: '-120'
    legend: 'False'
    type: complex
    update_time: update_period
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    comment: Baseband Waterfall
    fc: '0'
    fftsize: fft_size
    freqhalf: 'False'
    grid: 'True'
    gui_hint: main@0:1,4,1,196
    int_max: '-10'
    int_min: '-100'
    legend: 'False'
    type: complex
    update_time: update_period
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: FM MPX
    decim: samp_rate_FMMPX
    interp: samp_rate_audio_band
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate_FMMPX
    interp: samp_rate_RDS
    type: ccc
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters:
    comment: RDS1 Decoder
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters:
    comment: RDS1 output
    freq: freq_tune/1e6
    gui_hint: main@3:0,0,1,200
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    comment: PTY = Europe or US
    pty_locale: '0'
    reset: freq_tune
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import sip
      from PyQt5.QtWidgets import QWidget
      from PyQt5.QtGui import QPainter, QPen
      from PyQt5.QtCore import Qt

      class FreqCenterMarkerOverlay(QWidget):
          def __init__(self, plot_canvas):
              # Attach directly to the internal drawing canvas widget
              super().__init__(plot_canvas)
              self.plot_canvas = plot_canvas
              
              # Make this overlay fully transparent and click-through
              self.setAttribute(Qt.WA_TransparentForMouseEvents, True)
              self.setAttribute(Qt.WA_NoSystemBackground, True)
              self.setAttribute(Qt.WA_TranslucentBackground, True)
              
              # Keep perfect alignment with the canvas size
              self.plot_canvas.installEventFilter(self)
              self.setGeometry(self.plot_canvas.rect())
              self.show()

          def eventFilter(self, obj, event):
              if obj == self.plot_canvas and event.type() == event.Resize:
                  self.setGeometry(obj.rect())
              return super().eventFilter(obj, event)

          def paintEvent(self, event):
              painter = QPainter(self)
              pen = QPen(Qt.red, 1, Qt.DashLine)
              painter.setPen(pen)
              marker_x = int(self.width() / 2.0)
              painter.drawLine(marker_x, 0, marker_x, self.height())


      # --- Execute Smart Canvas Extraction ---
      raw_pointer = self.qtgui_freq_sink_x_0_1.qwidget()
      safe_sink_window = sip.wrapinstance(raw_pointer, QWidget)

      # Scan the widget tree to find the internal QwtPlotCanvas drawing box
      target_canvas = None
      for child in safe_sink_window.findChildren(QWidget):
          class_name = child.metaObject().className()
          if "Canvas" in class_name or "canvas" in child.objectName().lower():
              target_canvas = child
              break

      # Fallback to the top window frame if the child canvas tree is completely hidden
      if target_canvas is None:
          target_canvas = safe_sink_window

      # Attach the overlay directly onto the plot canvas grid
      self.custom_frequency_center_marker = FreqCenterMarkerOverlay(plot_canvas=target_canvas)
    comment: Baseband Center Marker
    section: main_after_init
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      # FM MPX Markers for GNU Radio Qt GUI Freq Sink
      import sip
      from PyQt5.QtWidgets import QWidget
      from PyQt5.QtGui import QPainter, QPen, QColor, QFont
      from PyQt5.QtCore import Qt, QRect

      class FreqCenterMarkerOverlay(QWidget):
          def __init__(self, plot_canvas, freq_sink):
              super().__init__(plot_canvas)
              self.plot_canvas = plot_canvas
              self.freq_sink = freq_sink  
              
              # Transparent click-through overlay setup
              self.setAttribute(Qt.WA_TransparentForMouseEvents, True)
              self.setAttribute(Qt.WA_NoSystemBackground, True)
              self.setAttribute(Qt.WA_TranslucentBackground, True)
              
              # Keep perfect alignment with the canvas size
              self.plot_canvas.installEventFilter(self)
              self.setGeometry(self.plot_canvas.rect())
              self.show()

          def eventFilter(self, obj, event):
              if obj == self.plot_canvas and event.type() == event.Resize:
                  self.setGeometry(obj.rect())
              return super().eventFilter(obj, event)

          def paintEvent(self, event):
              painter = QPainter(self)
              

              marker_pen = QPen(Qt.red, 1, Qt.DashLine)

              label_pen = QPen(Qt.black)
              font = QFont("Arial", 8)
              painter.setFont(font)
              
              # Canvas size and margins
              canvas_width = self.width()
              canvas_height = self.height()
              left_margin = 6.0
              right_margin = 20.0
              usable_width = canvas_width - left_margin - right_margin
              max_freq = 100.0  # Total scale span from 0 to 100 kHz
              
              # Dictionary linking specific target frequencies (kHz) to their names
              mpx_markers = {
                  0.0: "",
                  19.0: "Pilot",
                  38.0: "L-R",
                  57.0: "RDS1",
                  66.5: "RDS2DS1",
                  71.25: "RDS2DS2",
                  76.0: "RDS2DS3 / SCA",
                  100.0: ""
              }
              
              for freq, label_name in mpx_markers.items():

                  # Map the frequency directly into the padded graph region
                  x_pixel = int(left_margin + (freq / max_freq) * usable_width)
                  
                  if 0 <= x_pixel <= canvas_width:
                      #Draw the vertical marker line
                      painter.setPen(marker_pen)
                      painter.drawLine(x_pixel, 0, x_pixel, canvas_height)
                      
                      # Draw the text label
                      # Create a 2-line string containing the frequency value and its structural name
                      label_text = f"{int(freq)}kHz\n{label_name}"
                      
                      # Create a boundary box for text formatting (100px wide, centered over the line)
                      # Positioned 10 pixels down from the top edge of the plot canvas
                      text_rect = QRect(x_pixel - 50, 10, 100, 40)
                      painter.setPen(label_pen)
                      painter.drawText(text_rect, Qt.AlignHCenter | Qt.TextWordWrap, label_text)

      # --- Execute Smart Canvas Extraction ---
      raw_pointer = self.qtgui_freq_sink_x_0_0.qwidget()
      safe_sink_window = sip.wrapinstance(raw_pointer, QWidget)

      target_canvas = None
      for child in safe_sink_window.findChildren(QWidget):
          class_name = child.metaObject().className()
          if "QwtPlotCanvas" in class_name:
              target_canvas = child
              break

      if target_canvas is not None:
          self.mpx_markers = FreqCenterMarkerOverlay(target_canvas, self.qtgui_freq_sink_x_0_0)
      else:
          print("[Error] Could not locate QwtPlotCanvas in hierarchy.")
    comment: FM MPX Markers
    section: main_after_init
  states: {}
- name: snippet_0_1
  id: snippet
  parameters:
    code: |-
      import sip
      from PyQt5.QtWidgets import QWidget
      from PyQt5.QtGui import QPainter, QPen
      from PyQt5.QtCore import Qt

      class FreqCenterMarkerOverlay(QWidget):
          def __init__(self, plot_canvas):
              # Attach directly to the internal drawing canvas widget
              super().__init__(plot_canvas)
              self.plot_canvas = plot_canvas
              
              # Make this overlay fully transparent and click-through
              self.setAttribute(Qt.WA_TransparentForMouseEvents, True)
              self.setAttribute(Qt.WA_NoSystemBackground, True)
              self.setAttribute(Qt.WA_TranslucentBackground, True)
              
              # Keep perfect alignment with the canvas size
              self.plot_canvas.installEventFilter(self)
              self.setGeometry(self.plot_canvas.rect())
              self.show()

          def eventFilter(self, obj, event):
              if obj == self.plot_canvas and event.type() == event.Resize:
                  self.setGeometry(obj.rect())
              return super().eventFilter(obj, event)

          def paintEvent(self, event):
              painter = QPainter(self)
              pen = QPen(Qt.red, 1, Qt.DashLine)
              painter.setPen(pen)
              marker_x = int(self.width() / 2.0)
              painter.drawLine(marker_x, 0, marker_x, self.height())


      # --- Execute Smart Canvas Extraction ---
      raw_pointer = self.qtgui_freq_sink_x_1.qwidget()
      safe_sink_window = sip.wrapinstance(raw_pointer, QWidget)

      # Scan the widget tree to find the internal QwtPlotCanvas drawing box
      target_canvas = None
      for child in safe_sink_window.findChildren(QWidget):
          class_name = child.metaObject().className()
          if "Canvas" in class_name or "canvas" in child.objectName().lower():
              target_canvas = child
              break

      # Fallback to the top window frame if the child canvas tree is completely hidden
      if target_canvas is None:
          target_canvas = safe_sink_window

      # Attach the overlay directly onto the plot canvas grid
      self.custom_frequency_center_marker = FreqCenterMarkerOverlay(plot_canvas=target_canvas)
    comment: RDS1 Center Marker
    section: main_after_init
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: FM MPX
    stream_id: FM_MPX
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    comment: FM RDS
    stream_id: FM_RDS1
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RDS1_bits
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: RDS1_signal
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: Right
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: Left
  states: {}
- name: virtual_sink_8
  id: virtual_sink
  parameters:
    comment: FM SCA
    stream_id: FM_SCA
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: FM MPX
    stream_id: FM_MPX
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: FM RDS1
    stream_id: FM_RDS1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    comment: RDS1 bits
    stream_id: RDS1_bits
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    comment: RDS1 Signal
    stream_id: RDS1_signal
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    comment: Audio L-R
    stream_id: L-R
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    comment: Audio L+R
    stream_id: L+R
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    comment: Audio Left
    stream_id: Left
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    comment: Audio Right
    stream_id: Right
  states: {}
- name: virtual_source_8
  id: virtual_source
  parameters:
    comment: FM SCA
    stream_id: FM_SCA
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_agc_xx_0, '0', virtual_sink_3, '0']
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_1, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_8, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '0']
- [blocks_delay_0, '0', virtual_sink_4, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_7, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_6, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_1, '0', virtual_sink_5, '0']
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_1, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1, '0', blocks_sub_xx_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_1_0, '0', blocks_sub_xx_0, '1']
- [fir_filter_xxx_2, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', rational_resampler_xxx_1, '0']
- [freq_xlating_fir_filter_xxx_1_0_0, '0', analog_nbfm_rx_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [limesuiteng_sdrdevice_source_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', fir_filter_xxx_2, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [virtual_source_2, '0', rds_decoder_0, '0']
- [virtual_source_3, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_4, '0', fir_filter_xxx_1_0, '0']
- [virtual_source_5, '0', fir_filter_xxx_1, '0']
- [virtual_source_6, '0', audio_sink_0, '0']
- [virtual_source_6, '0', blocks_float_to_complex_0, '0']
- [virtual_source_7, '0', audio_sink_0, '1']
- [virtual_source_7, '0', blocks_float_to_complex_0, '1']
- [virtual_source_8, '0', freq_xlating_fir_filter_xxx_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
