options:
  parameters:
    author: Muthanna Alwahash
    category: Custom
    copyright: (c) 2026
    description: ADSB Decoder
    generate_options: no_gui
    id: file_ADSB_decode
    output_language: python
    title: ADSB Decoder
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: detect_thre
  id: variable
  parameters:
    value: '0.20'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: fft_y_max
  id: variable
  parameters:
    value: '-30'
  states: {}
- name: fft_y_min
  id: variable
  parameters:
    value: '-70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samp_rate_ADSB
  id: variable
  parameters:
    value: '6000000'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    comment: Decode bits
    error_corr: '"Conservative"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    comment: Generate bits
    fs: samp_rate_ADSB
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    comment: Detect Preambles
    fs: samp_rate_ADSB
    threshold: detect_thre
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: Draw threshold line
    const: detect_thre
    type: float
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Phase info not required
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: 2 channels > IQ Complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: File Sample Rate
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Recorded file
    file: /home/mkhuthir/rfdata/wav/ADSB/adsb.2021-11-26T15_03_30_573.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 0,0,1,100
    legend: 'False'
    name: '"Baseband"'
    type: complex
    ymax: fft_y_max
    ymin: fft_y_min
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    grid: 'True'
    gui_hint: 0,100,1,100
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '2'
    nconnections: '2'
    size: int(samp_rate_ADSB*150e-6)
    srate: int(samp_rate_ADSB)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: '0.01'
    ymax: '4'
    ymin: '0'
    yunit: '"Demod Data"'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: center_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 1,5,1,95
    int_max: fft_y_max
    int_min: fft_y_min
    legend: 'False'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Int. multiple of 
      ADSB 1Mbps data rate
    decim: samp_rate
    interp: samp_rate_ADSB
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: selected_sig
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: selected_sig
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5001
    timeout: '10'
  states: {}

connections:
- [adsb_decoder_0, decoded, zeromq_pub_msg_sink_0, in]
- [adsb_demod_0, '0', blocks_null_sink_0, '0']
- [adsb_demod_0, '0', qtgui_time_sink_x_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_1, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
