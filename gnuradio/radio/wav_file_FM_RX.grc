options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    description: FM Receiver from wave file
    generate_options: qt_gui
    id: wave_file_FM_RX
    output_language: python
    title: Wave File FM RX
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 99e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: shift_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,2,2
    label: Frequncy Shift
    start: '-samp_rate/2'
    step: 100e3
    stop: samp_rate/2
    value: 500e3
    widget: dial
  states: {}
- name: volume
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 2,0,2,2
    label: Volume
    maximum: '100'
    minimum: '0'
    scaleFactor: '0.1'
    showvalue: 'True'
    type: real
    value: '3'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate_audio
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*np.pi*shift_freq/samp_rate
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mkhuthir/rfdata/wav/Broadcast_FM/bfm.2021-12-16T14_23_16_147.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    ctrlpanel: 'True'
    fc: center_freq-shift_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,2,12,12
    legend: 'False'
    name: ''
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: samp_rate_audio*10
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle2_0, '0', blocks_rotator_cc_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
