options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    description: RDS receiver from wave file
    generate_options: qt_gui
    id: wav_file_FM_RX
    output_language: python
    title: Wave file FM RX
  states: {}

blocks:
- name: FM_fsk_deviation_hz
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: LPF_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 7.5e3
    gain: '1.0'
    samp_rate: samp_rate_FM_band
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: RDS_freq
  id: variable
  parameters:
    value: '57000'
  states: {}
- name: RDS_sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: SCA_freq
  id: variable
  parameters:
    value: '67000'
  states: {}
- name: SCA_fsk_deviation_hz
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 88.11e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samp_rate_FM_band
  id: variable
  parameters:
    value: 5*samp_rate_audio
  states: {}
- name: samp_rate_SCA
  id: variable
  parameters:
    value: samp_rate_audio*5
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,100
    label: FM Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: volume2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,100
    label: SCA Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.4'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate_audio
    max_dev: SCA_fsk_deviation_hz
    quad_rate: samp_rate_SCA
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*FM_fsk_deviation_hz)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate_FM_band/samp_rate_audio)
    comment: Wideband FM
    quad_rate: samp_rate_FM_band
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: FM Audio Mono
    samp_rate: samp_rate_audio
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: SCA Audio
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Wave file source
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: FM Volume
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: SCA Volume
    const: volume2
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Wave file sample rate
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Wave file
    file: /home/mkhuthir/rfdata/wav/FM_RDS/SDRuno_20200907_184033Z_88110kHz_FM_RDS.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: SCA_freq
    comment: SCA LPF
    decim: '1'
    samp_rate: samp_rate_SCA
    taps: LPF_taps
    type: fcc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    comment: Baseband Freq
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 5,0,4,100
    legend: 'False'
    name: ''
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_FM_band
    color1: '"green"'
    comment: SCA Freq
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 9,0,4,100
    legend: 'False'
    name: ''
    type: float
    ymax: '-10'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_FM_band
    color1: '"green"'
    comment: SCA Freq
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    legend: 'False'
    name: ''
    type: complex
    ymax: '-40'
    ymin: '-180'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_FM_band
    comment: SCA Waterfall
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 13,4,4,96
    int_max: '-10'
    int_min: '-100'
    legend: 'False'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_FM_band
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_SCA
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: file1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: file1
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fir_filter_xxx_1_0, '0', analog_nbfm_rx_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', qtgui_freq_sink_x_0_1, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
