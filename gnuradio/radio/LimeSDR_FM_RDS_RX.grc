options:
  parameters:
    author: Muthanna Alwahash
    category: Custom
    copyright: (c) 2026
    description: LimeSDR Stereo FM receiver and RDS Decoder
    generate_options: qt_gui
    id: LimeSDR_FM_RDS_RX
    output_language: python
    title: LimeSDR Stereo FM receiver and RDS Decoder
  states: {}

blocks:
- name: FM_Y_max
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,200,2,1
    label: '"Max"'
    orient: QtCore.Qt.Vertical
    rangeType: int
    start: '-60'
    step: '10'
    stop: '10'
    value: '0'
    widget: slider
  states: {}
- name: FM_Y_min
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,200,2,1
    label: '"Min"'
    orient: QtCore.Qt.Vertical
    start: '-200'
    step: '10'
    stop: '-70'
    value: '-160'
    widget: slider
  states: {}
- name: LO_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0,1, 100
    label: LO Freq.
    start: '87'
    step: '0.1'
    stop: '108'
    value: '92.6'
  states: {}
- name: NCO_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0,1, 100
    label: NCO Offset
    start: '-samp_rate/2'
    step: 100e3
    stop: samp_rate/2
    value: '0'
  states: {}
- name: baseband_Y_max
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,200,2,1
    label: '"Max"'
    orient: QtCore.Qt.Vertical
    rangeType: int
    start: '-60'
    step: '10'
    stop: '10'
    value: '0'
    widget: slider
  states: {}
- name: baseband_Y_min
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,200,2,1
    label: '"Min"'
    orient: QtCore.Qt.Vertical
    start: '-200'
    step: '10'
    stop: '-70'
    value: '-160'
    widget: slider
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: LO_freq*1e6 +NCO_offset
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 0,1, 100
    label: RF Gain
    start: '0'
    step: '1'
    stop: '49.6'
    value: '25'
  states: {}
- name: pilot_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: '240000'
    type: complex_band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: '151'
    samp_rate: '19000'
    sym_rate: 19000/8
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0,1, 100
    label: Volume
    start: '-20'
    step: '1'
    stop: '10'
    value: '-6'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '53'
    max_gain: '1000'
    rate: '2e-3'
    reference: '0.585'
    type: complex
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    comment: 75us = US, 50us = EUR
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    comment: 75us = US, 50us = EUR
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * math.pi * 19020 / 240000
    min_freq: 2 * math.pi * 18980 / 240000
    w: '0.001'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM Demodulator
    gain: (samp_rate / decimation) / (2*math.pi*75000)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: L+R
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: (len(pilot_taps) - 1) // 2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: L-R
    type: float
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2*math.pi / 100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Pilot
    decim: '1'
    taps: pilot_taps
    type: fcc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    comment: L+R
    decim: '5'
    taps: firdes.low_pass(1.0,240000,15e3,2e3)
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    comment: L-R
    decim: '5'
    taps: firdes.low_pass(-2.1,240000,15e3,2e3)
    type: fff
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps_manchester
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: Channel Selector
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 135000, 20000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    comment: RDS
    decim: '10'
    samp_rate: samp_rate / decimation
    taps: firdes.low_pass(1.0, samp_rate / decimation, 7.5e3, 5e3)
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: auto
    calibrate_dciq: Disabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: ''
    gain_generic: gain
    gfir_bandwidth: '0'
    link_format: i12
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: 20e6
    nco_offset: NCO_offset
    override_lms7002m_rx_gains: Disabled
    rf_freq: LO_freq*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    grid: 'True'
    gui_hint: 5,0,6,20
    legend: 'False'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    bw: samp_rate/decimation
    color1: '"green"'
    comment: Channel FFT
    fc: freq_tune
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,100,5,100
    legend: 'False'
    type: complex
    ymax: baseband_Y_max
    ymin: baseband_Y_min
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    comment: FM FFT
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 5,20,4,180
    legend: 'False'
    type: float
    ymax: FM_Y_max
    ymin: FM_Y_min
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate / decimation
    comment: FM Waterfall
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 9,25,8,175
    int_max: '-10'
    int_min: '-100'
    legend: 'False'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // decimation
    interp: '240000'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // decimation // 10
    interp: '19000'
    type: ccc
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters:
    freq: freq_tune
    gui_hint: 4,0,1,100
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    comment: PTY = Europe or US
    pty_locale: '0'
    reset: freq_tune
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '0']
- [blocks_delay_0, '0', fir_filter_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_1, '0', fir_filter_xxx_1_0, '0']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1, '0', blocks_sub_xx_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_1_0, '0', blocks_sub_xx_0, '1']
- [fir_filter_xxx_2, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', rational_resampler_xxx_1, '0']
- [limesuiteng_sdrdevice_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', fir_filter_xxx_2, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
