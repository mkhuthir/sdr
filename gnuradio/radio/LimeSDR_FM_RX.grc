options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    description: LimeSDR Mini 1.2 FM Receiver
    generate_options: qt_gui
    id: LimeSDR_FM_RX
    output_language: python
    title: LimeSDR FM Receiver
  states: {}

blocks:
- name: GFIR_bandwidth
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 1,0,1,2
    lbl: GFIR Bandwidth Hz
    maxFreqHz: samp_rate
    minFreqHz: '0'
    relBackgroundColor: gray
    value: 300e3
  states: {}
- name: LO_freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    gui_hint: 3,0,1,2
    lbl: LO Frequency Hz
    maxFreqHz: '109e+6'
    minFreqHz: '86e+6'
    outputmsgname: LO_freq
    relFontColor: green
    value: '95000000'
  states: {}
- name: NCO_offset
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 4,0,1,2
    lbl: NCO Offset Hz
    maxFreqHz: samp_rate
    minFreqHz: '-samp_rate'
    relFontColor: green
    value: '0'
  states: {}
- name: RF_gain
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 5,0,1,1
    label: RF Gain dB
    maximum: '100'
    minimum: '0'
    relBackgroundColor: yellow
    showvalue: 'True'
    type: int
    value: '20'
  states: {}
- name: RX_LPF_cutoff
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 2,0,1,2
    lbl: RX Low Pass Filter cutoff frequency Hz
    maxFreqHz: 130e6
    minFreqHz: 4e6
    relBackgroundColor: gray
    value: 4e6
  states: {}
- name: VFO_freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 6,0,1,2
    lbl: VFO Freq Hz
    maxFreqHz: 6e12
    minFreqHz: '0'
    readOnly: 'True'
    value: LO_freq
  states: {}
- name: antenna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,2
    label: LNA Path
    label0: LNAW
    label1: LNAH
    label2: LNAL
    label3: auto
    num_opts: '4'
    option0: LNAW
    option1: LNAH
    option2: LNAL
    option3: auto
    orient: Qt.QHBoxLayout
    type: string
    value: auto
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: volume
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 5,1,1,1
    label: Volume
    maximum: '100'
    minimum: '0'
    relBackgroundColor: orange
    scaleFactor: '0.1'
    showvalue: 'True'
    type: real
    value: '3'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate_audio
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: antenna
    calibrate_dciq: Enabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: ''
    gain_generic: RF_gain
    gfir_bandwidth: GFIR_bandwidth
    link_format: i16
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: RX_LPF_cutoff
    nco_offset: NCO_offset
    override_lms7002m_rx_gains: Disabled
    rf_freq: LO_freq
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    ctrlpanel: 'True'
    fc: LO_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,2,12,12
    legend: 'False'
    name: ''
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/10000)
    interp: int(samp_rate_audio/1000)
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', qtgui_freq_sink_x_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
