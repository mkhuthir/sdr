options:
  parameters:
    author: Muthanna Alwahash
    copyright: (c) 2026
    description: LimeSDR Mini 1 FM Receiver
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: LimeSDR FM Receiver
  states: {}

blocks:
- name: GFIR_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: GFIR bandwidth Hz
    start: '0'
    step: 1e3
    stop: samp_rate
    value: 300e3
  states: {}
- name: RF_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: RF Gain dB
    min_len: '70'
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: RX_LPF_cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: LPF cutoff Hz
    start: 4e6
    step: '1'
    stop: 160e6
    value: 4e6
  states: {}
- name: antenna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: LNA Path
    label0: LNAW
    label1: LNAH
    label2: LNAL
    label3: Auto
    num_opts: '4'
    option0: LNAW
    option1: LNAH
    option2: LNAL
    option3: Auto
    orient: Qt.QHBoxLayout
    type: string
    value: Auto
    widget: radio_buttons
  states: {}
- name: baseband
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Center Freq MHz
    start: '87'
    step: '0.1'
    stop: '109'
    value: '95'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: volume
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 5,0,2,1
    label: Volume
    maximum: '100'
    minimum: '0'
    minsize: '50'
    scaleFactor: '0.1'
    showvalue: 'True'
    type: real
    value: '3'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate_audio
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: antenna
    calibrate_dciq: Enabled
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: ''
    gain_generic: RF_gain
    gfir_bandwidth: GFIR_bandwidth
    link_format: i16
    lms7002m_gain_lna: '0'
    lms7002m_gain_pga: '0'
    lms7002m_gain_tia: '-3'
    lpf: RX_LPF_cutoff
    nco_offset: '0.0'
    override_lms7002m_rx_gains: Disabled
    rf_freq: baseband*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"green"'
    ctrlpanel: 'True'
    fc: baseband*1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,2,15,8
    legend: 'False'
    name: FFT
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/10000)
    interp: int(samp_rate_audio/1000)
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', qtgui_freq_sink_x_0, '0']
- [limesuiteng_sdrdevice_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
